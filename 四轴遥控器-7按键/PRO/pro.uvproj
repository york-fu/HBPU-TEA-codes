# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\NRF24L01;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\USER;..\HARDWARE;..\HARDWARE\NRF24L01;..\HARDWARE\timer;..\HARDWARE\KEY
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP.A51
    ../USER/: main.c sys.c usart.c
  group HARDWARE
    ../HARDWARE/NRF24L01/: nrf24l01.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/KEY/: key.c
